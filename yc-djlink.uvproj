# Keil uVision project yc-djlink.uvproj, settings and files
target WTarget 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: yc-djlink +hex
  c flags: Optimize=7 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c CH9329.c delay.c uart.c
